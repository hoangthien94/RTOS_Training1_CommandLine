# Keil uVision project RTOS_Training1.uvprojx, settings and files
target Training 1 (ARM-ADS)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.0.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTOS_Training1
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_TM4C123_RB1 UART_BUFFERED
  c misc: --c99
  c include: C:\ti\TivaWare_C_Series-2.1.0.12573;C:\ti\TivaWare_C_Series-2.1.0.12573\examples\boards\ek-tm4c123gxl
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: .\Objects\RTOS_Training1.sct
  group Source Group 1
    ./: main.c startup_rvmdk.s
    C:/ti/TivaWare_C_Series-2.1.0.12573/utils/: cmdline.c uartstdio.c ustdlib.c
  group Libraries
    C:/ti/TivaWare_C_Series-2.1.0.12573/driverlib/ccs/Debug/: driverlib.lib
  group Documentation
    ./: Readme.txt
